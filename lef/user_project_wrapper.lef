VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO full_chip
  CLASS BLOCK ;
  FOREIGN full_chip ;
  ORIGIN 0.000 0.000 ;
  SIZE 35.000 BY 30.000 ;
  OBS
      LAYER met1 ;
        RECT 0.800 28.800 34.600 29.200 ;
        RECT 0.800 1.200 1.200 28.800 ;
        RECT 1.600 23.200 13.600 23.400 ;
        RECT 1.600 19.600 1.800 23.200 ;
        RECT 13.400 19.600 13.600 23.200 ;
        RECT 1.600 19.400 13.600 19.600 ;
        RECT 1.600 18.600 11.600 18.800 ;
        RECT 1.600 14.000 1.800 18.600 ;
        RECT 11.400 14.000 11.600 18.600 ;
        RECT 19.000 17.800 23.000 18.000 ;
        RECT 1.600 13.800 11.600 14.000 ;
        RECT 12.400 15.800 18.400 16.000 ;
        RECT 1.600 13.000 11.600 13.200 ;
        RECT 1.600 7.400 1.800 13.000 ;
        RECT 11.400 7.400 11.600 13.000 ;
        RECT 12.400 12.200 12.600 15.800 ;
        RECT 18.200 12.200 18.400 15.800 ;
        RECT 19.000 14.200 19.200 17.800 ;
        RECT 22.800 14.200 23.000 17.800 ;
        RECT 19.000 14.000 23.000 14.200 ;
        RECT 12.400 12.000 18.400 12.200 ;
        RECT 19.000 13.000 27.000 13.200 ;
        RECT 1.600 7.200 11.600 7.400 ;
        RECT 12.400 11.300 18.400 11.500 ;
        RECT 1.600 6.400 8.600 6.600 ;
        RECT 1.600 1.800 1.800 6.400 ;
        RECT 8.400 1.800 8.600 6.400 ;
        RECT 12.400 6.200 12.600 11.300 ;
        RECT 18.200 6.200 18.400 11.300 ;
        RECT 19.000 7.400 19.200 13.000 ;
        RECT 26.800 7.400 27.000 13.000 ;
        RECT 19.000 7.200 27.000 7.400 ;
        RECT 12.400 6.000 18.400 6.200 ;
        RECT 19.000 6.400 25.000 6.600 ;
        RECT 12.400 5.400 17.400 5.600 ;
        RECT 1.600 1.600 8.600 1.800 ;
        RECT 9.000 4.400 12.000 4.600 ;
        RECT 9.000 1.800 9.200 4.400 ;
        RECT 11.800 1.800 12.000 4.400 ;
        RECT 9.000 1.600 12.000 1.800 ;
        RECT 12.400 1.800 12.600 5.400 ;
        RECT 17.200 1.800 17.400 5.400 ;
        RECT 12.400 1.600 17.400 1.800 ;
        RECT 19.000 1.800 19.200 6.400 ;
        RECT 24.800 1.800 25.000 6.400 ;
        RECT 19.000 1.600 25.000 1.800 ;
        RECT 33.800 1.200 34.200 28.800 ;
        RECT 0.800 0.800 34.600 1.200 ;
      LAYER met2 ;
        RECT 11.600 13.000 12.700 13.300 ;
        RECT 11.600 10.000 12.700 10.300 ;
        RECT 25.000 5.000 25.300 7.500 ;
        RECT 8.600 4.000 12.700 4.300 ;
        RECT 17.400 3.600 19.300 3.900 ;
      LAYER met3 ;
        RECT 0.000 29.400 35.000 30.000 ;
        RECT 0.000 0.600 0.600 29.400 ;
        RECT 34.400 0.600 35.000 29.400 ;
        RECT 0.000 0.000 35.000 0.600 ;
  END
END full_chip
END LIBRARY

